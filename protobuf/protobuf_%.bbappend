SRC_URI = "git://github.com/protocolbuffers/protobuf.git"
